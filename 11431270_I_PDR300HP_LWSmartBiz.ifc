Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-15T08:43:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 15 08:43:06 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{7C412013-E441-4F5C-8DE1-7348DA72ED8C}\ifc * Database version: 5507 * Database creation date: Thu Jul 15 08:43:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 15 08:43:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 15 08:43:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 52300001_I_11431270_PDR300HP_LWSmartBiz, 11431270_I_PDR300HP_LWSmartBiz:52300001_I_11431270_PDR300HP_LWSmartBiz:209956
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Orange, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, Default, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 52300001_I_11431270_PDR300HP_LWSmartBiz
